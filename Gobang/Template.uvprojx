# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_DMP,MPL_LOG_NDEBUG=1,EMPL,MPU6050,EMPL_TARGET_STM32F4
  c include: .\User;.\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\User\mpu6050\driver\eMPL;.\User\mpu6050\driver\include;.\User\mpu6050\driver\stm32L;.\User\mpu6050\eMPL-hal;.\User\mpu6050\mllite;.\User\mpu6050\mpl
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./User/: main.c stm32f10x_it.c
    ./User/lcd/: bsp_ili9341_lcd.c
    ./User/SysTick/: bsp_SysTick.c
    ./User/usart/: bsp_usart.c
    ./User/font/: fonts.c
    ./User/i2c/: bsp_i2c.c
    ./User/led/: bsp_led.c
    ./User/key/: bsp_key.c
    ./User/Exti/: bsp_exti.c
  group STARTUP
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group FWLB
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c core_cm3.h
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c stm32f10x.h system_stm32f10x.h
  group MPU_eMPL
    ./User/mpu6050/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ./User/mpu6050/driver/stm32L/: log_stm32.c
    ./User/mpu6050/eMPL-hal/: eMPL_outputs.c
  group MPU_mllite
    ./User/mpu6050/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
  group MPU_mpl
    ./User/mpu6050/mpl/: libmpllib.lib
